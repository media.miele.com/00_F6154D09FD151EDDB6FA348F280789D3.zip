Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-04-11T08:29:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 11 08:29:54 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\64887489-faff-45f9-a1fb-7ca8fea81179\228e9a90-63d6-47e5-a7b8-2dcefee4d0f0\ifc * Database version: 5507 * Database creation date: Tue Apr 11 08:29:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 11 08:29:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 11 08:29:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12153750_USA_KFN9859iDE_RE:38985951_USA_12153750_KFN9859iDE_RE, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 38985951_USA_12153750_KFN9859iDE_RE
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 38985951_USA_12153750_KFN9859iDE_RE
Type - Pset_ProvisionForVoid - Width: 757 mm; Height: 2027 mm; Depth: 610 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_BRWS, z_Miele_Connection_Electric, z_Miele_Connection_Water_IN
Pset_BuildingElementProxyCommon - sets with these values: 2
